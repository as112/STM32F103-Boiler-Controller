# Keil uVision project Lesson.uvprojx, settings and files
target Lesson (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lesson +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\workspace;.\CMSIS\inc;.\Code\inc;.\STM32F10x_StdPeriph_Driver\inc;.\hd44780\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group Code
    ./Code/src/: main.c delay.c gpio.c i2cm.c ds18b20.c onewire.c
  group SPL
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_iwdg.c
  group hd44870
    ./hd44780/src/: cp866toepson.c cp1251toepson.c hd44780.c pcf8574.c
